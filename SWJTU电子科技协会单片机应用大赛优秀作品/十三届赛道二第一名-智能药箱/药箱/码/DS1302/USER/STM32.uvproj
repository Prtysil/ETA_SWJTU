# Keil uVision project STM32.uvproj, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DS1302;..\HARDWARE\OLED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\TB6612FNG;..\HARDWARE\DS18B20;..\HARDWARE\light;..\HARDWARE\PWM;..\HARDWARE\Delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../SYSTEM/delay/: delay.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c
    ../CORE/STARTUP/: startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c
  group HARDWARE
    ../HARDWARE/BEEP/: BEEP.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DS1302/: DS1302.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/light/: LightSensor.c LightSensor.h
    ../HARDWARE/DS18B20/: DS18B20.c DS18B20.h
    ../HARDWARE/Delay/: Delay.c Delay.h
